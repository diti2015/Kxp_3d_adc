# Keil uVision project 3d_adc.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F350 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0x1FF) IROM(0-0x1FFF) CLOCK(50000000)
  output: 3d_adc_spi_cz +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./src/: 3d_adc_uart.c 3d_adc_adc.c 3d_adc_init.c 3d_adc_main.c 3d_adc_spi.c
